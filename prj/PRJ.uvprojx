# Keil uVision project PRJ.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: pure +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\inc;..\driver\inc;.\src;.\User;.\User\led;.\User\usart;.\User\timer;.\User\ir;.\User\2.4G;.\User\spi0
  asm include: .\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group src
    ./src/: system.c startup.s AM8813_misc.c
  group lib
    ../driver/src/: ckcu.c rstcu.c adc.c gpio.c gptm.c pdma.c spi.c usart.c lcd.c flash.c i2c.c misc.c pwrcu.c rtc.c wdt.c crc.c comp.c trng.c can.c
  group User
    ./src/: exception.c main.c
    ./User/led/: bsp_led.c
    ./User/usart/: bsp_usart.c
    ./User/timer/: bsp_timer.c
    ./User/ir/: remote_handle.c ir_decode.c
    ./User/spi0/: bsp_spi.c
  group DOC
    ./User/: READ_ME.txt
  group 2.4G
    ./User/2.4G/: BK2425_Initialization_141015.c BK2425_TxRx.c Test_Func.c
